# Keil uVision project NRF24L01.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: NRF24L01 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\Lib\cmsis;..\Lib\inc;..\User;..\User\NRF24L01
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Start
    ../Lib/startup/arm/: startup_stm32f10x_hd.s
  group Lib
    ../Lib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c
    ../User/: system_stm32f10x.c
  group User
    ../User/: main.c stm32f10x_it.c stm32f10x_conf.h
    ../Lib/cmsis/: stm32f10x.h
  group Drive
    ../User/: usart.c
    ../User/NRF24L01/: NRF24L01.c
